# Keil uVision project Terminal.uvproj, settings and files
target DebugInFlash (ARM-ADS)
  device: LPC1752 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10003FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: TerminalV08
  c flags: OneElfS=1
  c include: ..\App;..\BSP;..\BSP\RF;..\CSP;..\CSP\SSP;..\CSP\UART;..\ucos\Ports;..\ucos\Source
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x4000
  group System
    ../CSP/Startup/: startup_LPC17xx.s
    ../CSP/Common/: core_cm3.c system_LPC17xx.c
  group u/COS - Ports
    ../ucos/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group u/COS - Source
    ../ucos/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c ucos_ii.c ucos_ii.h os_tmr.c
  group CSP
    ../CSP/: csp.c
    ../CSP/UART/: csp_uart.c
    ../CSP/SSP/: csp_ssp.c
  group BSP
    ../BSP/: bsp.c
    ../BSP/RF/: bsp_nRF905.c
  group App
    ../App/: app.c
  group Readme
    ./: Readme.txt
